PROGRAM MAIN
VAR
END_VAR

P_IEC61850MAIN();

END_PROGRAM
